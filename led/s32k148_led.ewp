# IAR project s32k148_led.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K148 NXP S32K148
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; CPU_S32K144
  ICCARM.CCIncludePath2: Src\SDK\platform\devices; Src\SDK\platform\devices\S32K144\include; Src\SDK\platform\devices\common; Src\SDK\platform\drivers\inc; Src\SDK\platform\drivers\src\clock\S32K1xx; Src\SDK\platform\drivers\src\pins; Src\board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: s32k148_led.srec
  ILINK.IlinkOutputFile: s32k148_led.out
  ILINK.IlinkIcfFile: Src\Project_Settings\Linker_Files\S32K144_64_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Src
    Src/: main.c
  group Src/board
    Src/board/: clock_config.c pin_mux.c
  group Src/Project_Settings/Startup_Code
    Src/Project_Settings/Startup_Code/: startup_S32K144.s
  group Src/SDK/platform/devices
    Src/SDK/platform/devices/: startup.c
  group Src/SDK/platform/devices/S32K144/startup
    Src/SDK/platform/devices/S32K144/startup/: system_S32K144.c
  group Src/SDK/platform/drivers/src/clock/S32K1xx
    Src/SDK/platform/drivers/src/clock/S32K1xx/: clock_S32K1xx.c
  group Src/SDK/platform/drivers/src/interrupt
    Src/SDK/platform/drivers/src/interrupt/: interrupt_manager.c
  group Src/SDK/platform/drivers/src/pins
    Src/SDK/platform/drivers/src/pins/: pins_driver.c pins_port_hw_access.c
