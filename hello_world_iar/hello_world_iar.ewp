# IAR project hello_world_iar.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT
  ICCARM.IExtraOptions: --debug; --no_wrap_diagnostics
  ICCARM.CCIncludePath2: src; src\startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: src\startup
  OBJCOPY.OOCOutputFile: hello_world_iar.srec
  ILINK.IlinkOutputFile: hello_world_IAR.elf
  ILINK.IlinkIcfFile: src\linker\S32K148_256_flash.icf
  ILINK.IlinkExtraOptions: --no_wrap_diagnostics
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\platform\drivers\inc; ..\..\..\..\platform\devices; ..\..\..\..\platform\devices\common; ..\..\..\..\platform\devices\S32K144\include; src
  OBJCOPY.OOCOutputFile: hello_world_IAR.srec
  ILINK.IlinkExtraOptions: --no_wrap_diagnostics; --no_library_search
  group src
    src/: main.c
  group startup
    src/startup/: startup.c startup_S32K148.s system_S32K148.c
